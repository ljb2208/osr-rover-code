Commit message: New odom node

File: osr_description/urdf/osr_description copy.urdf (robot description, URDF)
Before this commit: robot osr_description, 4 links, 3 joints
Joints:
- joint imu_joint: origin xyz=0.12 0 0.50 rpy=0 0 0 -> xyz=0.14 0 0.50 rpy=0 0 0
